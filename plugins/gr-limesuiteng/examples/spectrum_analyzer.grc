options:
  parameters:
    author: Lime Microsystems
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Signal analyzer
  states: {}

blocks:
- name: analog_filter
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: Analog filter bandwidth [MHz]
    type: real
    value: samp_rate/1e6
  states: {}
- name: baseband
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: RX Baseband [MHz]
    type: real
    value: '805'
  states: {}
- name: digital_filter
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Digital filter bandwidth [MHz]
    type: real
    value: samp_rate/1e6 - 0.3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Gain [dB]
    min_len: '70'
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: lna_path
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,1,1,1
    label: LNA Path
    label0: LNAW
    label1: LNAH
    label2: LNAL
    num_opts: '3'
    option0: LNAW
    option1: LNAH
    option2: LNAL
    type: string
    value: LNAW
  states: {}
- name: nco
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: NCO [MHz]
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: limesuiteng_sdrdevice_source_0
  id: limesuiteng_sdrdevice_source
  parameters:
    antenna: lna_path
    channel_indexes: '[0]'
    chip_index: '0'
    custom_config_file: ''
    data_format: fc32
    deviceHandleHint: Mini
    gain_generic: gain
    lpf: 20e6
    nco_offset: nco*1e6
    rf_freq: baseband*1e6
    rf_oversampling: auto
    sample_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: baseband*1e6
    fftsize: '4096'
    gui_hint: 3,0,2,2
    showrf: 'True'
    type: complex
  states: {}

connections:
- [limesuiteng_sdrdevice_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-705-g4ce72612
